# Autodesk Inventor part: 가변스프링
## iProperties
Created: 2015-01
Part Number: 가변스프링
Document SubType Name: Modeling
Designer: elite
Density: 1 g/cm^3
Author: elite
